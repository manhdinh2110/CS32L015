# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::.\ARMCLANG)
  device: CS32L015 Chipsea
  pack: Chipsea.CS32L015_DFP.1.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=..\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Common;..\Inc;..\Src;.\RTE\Device\CS32L015
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/User
    ../Src/: main.c cs32l015_hal_msp.c cs32l015_it.c
  group Common
    ../../../../Common/: log.c util.c cs32l015_starterkit.c
  group Doc
    ../: readme.md
software components: CMSIS:CORE 6.1.0, Device:HAL:ADC 1.0.0, Device:HAL:AWT 1.0.0, Device:HAL:BASTIM 1.0.0, Device:HAL:BEEP 1.0.0, Device:HAL:CLKTRIM 1.0.0, Device:HAL:CORTEX 1.0.0, Device:HAL:CRC 1.0.0, Device:HAL:FLASH 1.0.0, Device:HAL:FWDT 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.5, Device:HAL:LPTIM 1.0.0, Device:HAL:LPUART 1.0.5, Device:HAL:LVD 1.0.0, Device:HAL:OPA 1.0.5, Device:HAL:OWI 1.0.0, Device:HAL:PCA 1.0.0, Device:HAL:PWR 1.0.0, Device:HAL:RCC 1.0.5, Device:HAL:RTC 1.0.0, Device:HAL:SPI 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:UART 1.0.5, Device:HAL:VC 1.0.5, Device:HAL:WWDT 1.0.0, Device:Startup 1.0.0
